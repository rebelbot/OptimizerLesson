# Keil uVision project Optimizer.uvprojx, settings and files
target STM32L476G-Discovery (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Optimzer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L476G_DISCO_REVB,BSP_AUDIO_USE_RTOS,ARM_MATH_CM4, LAB0
  c misc: --C99
  c include: ..\Core\inc;..\Config;..\Modules\compass;..\Modules\main_app;..\..\..\..\Utilities\CPU;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32L476G-Discovery;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../Drivers/BSP/Components/lsm303c/: lsm303c.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c tasks.c list.c croutine.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c SlidingWindow.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dfsdm.c stm32l4xx_ll_fmc.c stm32l4xx_hal.c stm32l4xx_hal_crc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_lcd.c stm32l4xx_hal_cortex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_spi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_adc.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_tim.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_qspi.c
  group Drivers/BSP/STM32L476G-Discovery
    ../../../../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery_glass_lcd.c stm32l476g_discovery.c stm32l476g_discovery_gyroscope.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
